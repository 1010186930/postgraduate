<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\build\iar\hello_world\hello_world_K60.ewp</path>
  </project>
  <batchBuild/>
</workspace>


