# Keil uVision project airvalvepid.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: arivalvepid +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\ADC;..\STM32F10x_FWLib\src;..\HARDWARE\GUI;..\HARDWARE\RS485;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\SYSTEM\usart;..\HARDWARE\PID;..\HARDWARE\GP8202;..\HARDWARE\I2C;..\HARDWARE\CRC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/GUI/: GUI.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: time.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/GP8202/: GP8202.c
    ../HARDWARE/I2C/: myiic.c
    ../../PID控制气阀/HARDWARE/MODBUS/: modbus.c
    ../../PID控制气阀/HARDWARE/CRC/: crc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_tim.c
  group README
    ../: README.TXT
